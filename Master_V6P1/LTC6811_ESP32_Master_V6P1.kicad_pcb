# Repository tetra-aero/LTC6811_ESP32 (continued)

## KiCad design LTC6811_ESP32_V1p4/LTC6811_ESP32_V1p4.kicad_pcb (continued)

Parts:
C32, C33, C37: 100nF/100V; C_0603_1608Metric; MPN CL10B104KC8NNNC
C34, C35: 10nF/100V; C_0603_1608Metric; MPN GCM188R72A103KA37D
C36: 1uF/25V; C_0603_1608Metric; MPN 0603B105K250XD
J5: UART /NC; PinHeader_1x04_P2.54mm_Vertical; MPN G800W304018EU
J6: JTAG /NC; PinHeader_1x04_P2.54mm_Vertical; MPN G800W304018EU
J7: Boot Option /NC; PinHeader_1x02_P2.54mm_Vertical; MPN G800W306018EU
R43: 10K; R_0603_1608Metric; MPN RMCF0603FT10K0
R44: 806R; R_0603_1608Metric; MPN RC0603FR-07806RL
R45, R46: 51R; R_0603_1608Metric; MPN RC0603JR-0751RL
R47: 1.2K; R_0603_1608Metric; MPN RC0603JR-071K2L
R48: 2K; R_0603_1608Metric; MPN RC0603FR-072KL
TR2: HM2108NL; MPN HM2108NL
U8: ESP32-DevKitC V4; ESP32-DevKitc V4_DIP-38_27.9mm×48.2mm; MPN ESP32-DEVKITC-32E
U9: LTC6820; MSOP-16_3x4mm_P0.5mm; MPN LTC6820IMS#PBF

Connections:
/MA: TR2.4; also elsewhere on the board
/MCU/5V: U8.19 (5V)
/MCU/Boot: J7.1, U8.25 (IO0)
/MCU/CAN_RX: J5.2, U8.34 (RXD0)
/MCU/CAN_TX: J5.3, U8.35 (TXD0)
/MCU/IM: R46.1, TR2.3, U9.10 (IM)
/MCU/IP: R45.2, TR2.1, U9.11 (IP)
/MCU/MISO: R48.2, U8.31 (IO19), U9.3 (MISO)
/MCU/MOSI: U8.37 (IO23), U9.2 (MOSI)
/MCU/MTCK: J6.4, U8.15 (IO13)
/MCU/MTDI: J6.2, U8.13 (IO12)
/MCU/MTDO: J6.3, U8.23 (IO15)
/MCU/MTMS: J6.1, U8.12 (IO14)
/MCU/NRST: C33.2, R43.2, U8.2 (EN)
/MCU/SCK: U8.30 (IO18), U9.4 (SCK)
/MCU/SCL: U8.36 (IO22); also elsewhere on the board
/MCU/SDA: U8.33 (IO21); also elsewhere on the board
/MCU/SS: U8.29 (IO5), U9.5 (CSB)
/PA: TR2.6; also elsewhere on the board
unnamed: C34.1, TR2.2
unnamed: C35.2, R45.1, R46.2
unnamed: R47.1, U9.16 (IBIAS)
unnamed: R44.1, R47.2, U9.15 (ICMP)

Notes on the sheet:
12位ADC最小测量电压为0.8mV
Boot Option
UART DOWNLOAD
Minimum 500mA
For Debugging

Parts:
C2, C28: 100nF/100V; C_0603_1608Metric; MPN CL10B104KC8NNNC
C3: 2.2uF/25V; C_0603_1608Metric; MPN GRM188R61E225KA12D
C19: 10uF/16V; C_0805_2012Metric; MPN CL21A106KOQNNNE
C26: 4.7uF/16V; C_0603_1608Metric; MPN CL10A475KO8NNNC
D1, D3: LED Red; LED_0603_1608Metric; MPN LTST-C190KRKT
D4, D5: MBR0520; D_SOD-123; MPN MBR0520-TP
J1: PB MB; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical; MPN B2P-VH
L1: 3.3uH; L_Bourns_SRP5030T; MPN SRP5030CC-3R3M
R1, R10: 470R; R_0603_1608Metric; MPN RC0603JR-07470RL
R28: 22.1K; R_0603_1608Metric; MPN RMCF0603FT22K1
R37: 100K; R_0603_1608Metric; MPN RC0603JR-07100KL
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
TR1: Transformer; WURTH-760390015; MPN 760390015
U1: TPS76350; SOT-23-5; MPN TPS76350DBVR
U4: SN6501DBV; SOT-23-5; MPN SN6501DBVR
U7: LMR51420XDDCR; SOT-23-6_Handsoldering; MPN LMR51420XDDCR

Connections:
+12V: C3.1, J1.2, U7.3 (VIN), U7.5 (EN); also elsewhere on the board
unnamed: D1.2 (A), R1.1
unnamed: D3.2 (A), R10.1
unnamed: D4.2 (A), TR1.4
unnamed: C2.1, C26.1, D4.1 (K), D5.1 (K), U1.1 (VIN), U1.3 (EN)
unnamed: D5.2 (A), TR1.6
unnamed: TR1.3, U4.1 (D1)
unnamed: TR1.1, U4.3 (D2)
unnamed: C28.2, U7.6 (CB)
unnamed: C28.1, L1.1, U7.2 (SW)

Parts of its further copies:
C1, C10, C13, C24: 10uF/16V; C_0805_2012Metric; MPN CL21A106KOQNNNE
R38: 22.1K; R_0603_1608Metric; MPN RMCF0603FT22K1

Notes on the sheet:
1:2.2
I_{Max}=2A
Isolated power supply
750319693 1:2.29
4.5 V to 36 V

Parts:
BAT1: BAT-; Battery_6mm×10mm_Cell_half_2
BAT-1: BAT-; Battery_6mm×10mm_Cell_half_2
C4, C7: 330pF/100V; C_0603_1608Metric; MPN GRM188R72A331KA01D
C5, C6, C8, C9, C18, C19, C20, C21, C23: 100nF/100V; C_0603_1608Metric; MPN CL10B104KC8NNNC
C11, C12: 2.2uF/25V; C_0603_1608Metric; MPN GRM188R61E225KA12D
C14, C15: 2.2nF/16V; C_0603_1608Metric; MPN C0603C222K4RECAUTO
C16, C17: 220pF/50V; C_0603_1608Metric; MPN GCM1885C1H221JA16D
C71: 1uF/25V; C_0603_1608Metric; MPN 0603B105K250XD
R9, R11, R12, R14: 470KΩ ±0.1% 250mW; R_0805_2012Metric; MPN ERJ-PB6B4703V
R13: 0.1MR 1% 15W; R_PSR500HTQFB0L10_Metric_Pad5.2x8.75mm_HandSolder; MPN PSR500HTQFB0L10
R15: 1KΩ ±0.1% 250mW; R_0805_2012Metric; MPN ERJ-PB6B1001V
R16, R17, R18, R24, R25, R26, R27, R32: 1K; R_0603_1608Metric; MPN CRCW06031K00FKEA
R19: 10R; R_0603_1608Metric; MPN RC0603JR-0710RL
R20, R21, R22, R23: 100R; R_0603_1608Metric; MPN RC0603FR-07100RL
R28, R29: 5.6K; R_0603_1608Metric; MPN RC0603JR-075K6L
R30, R31: 3.3K; R_0603_1608Metric; MPN RC0603FR-073K3L
R33, R34: 33K; R_0603_1608Metric; MPN RC0603FR-0733KL
R35, R36: 4.7K; R_0603_1608Metric; MPN RC0603JR-074K7L
U2: AMC1301 or AMC1302; SSO-8_6.8x5.9mm_P1.27mm_Clearance8mm; MPN AMC1301DWV
U3: AMC1301; SSO-8_6.8x5.9mm_P1.27mm_Clearance8mm; MPN AMC1301DWV
U5: OPA2197IDR; SOIC-8_3.9x4.9mm_Pitch1.27mm; MPN OPA2197IDR
U6: ISL28022; MSOP-10_3x3mm_P0.5mm; MPN ISL28022FUZ-T7A

Connections:
+12V: C23.1, C71.2, U5.8 (V+); also elsewhere on the board
/BAT+: R9.1; also elsewhere on the board
/MCU/SCL: R35.2, U6.5 (SCL); also elsewhere on the board
/MCU/SDA: R36.2, U6.4 (SDA); also elsewhere on the board
/PowerMonitor/BAT-: BAT-1.1, R13.2, R17.1
/PowerMonitor/VBAT_SENSE: C18.2, R34.2, U5.7, U6.8 (Vbus)
unnamed: C14.1, R20.1, R24.1
unnamed: C14.2, R21.1, R25.1
unnamed: C15.1, R22.1, R26.1
unnamed: C15.2, R23.1, R27.1
unnamed: C16.1, R24.2, R30.2
unnamed: C16.2, R25.2, R31.2
unnamed: C17.2, R27.2, R29.1
unnamed: R9.2, R11.1
unnamed: R11.2, R12.1
unnamed: R12.2, R14.1
unnamed: R14.2, R15.1, R19.1
unnamed: C4.2, R17.2, U2.3 (VINN)
unnamed: C4.1, R16.2, U2.2 (VINP)
unnamed: R20.2, U2.6 (VOUTN)
unnamed: R21.2, U2.7 (VOUTP)
unnamed: C7.2, R18.1, U3.3 (VINN)
unnamed: C7.1, R19.2, U3.2 (VINP)
unnamed: R22.2, U3.6 (VOUTN)
unnamed: R23.2, U3.7 (VOUTP)
unnamed: R29.2, R33.1, U5.5 (+)
unnamed: C20.2, R31.1, R32.2, U6.9 (Vin-)

Notes on the sheet:
DeltaVmax= Vshuntmax*Factor*(1/3.3+1+3.3) Factor : - AMC1301 = 8.2 - AMC1302 = 40 Vshuntmax: - AMC1301 : 0.25V - AMC1302 : 0.05V for AMC1302 DeltaVmax=0.263V
note that this works only for positive signals.
2nd order filter (fc=240khz)
±250mV
33K/5.6K =5.8929倍
Voutmax= (Vinmax*(1k/(470k*4+1k))*8.2)*(33k/5.6k) Vinmax= 450V Voutmax=11.56V
8.2倍
26.4mV 实际值24.6mV
1.277V 实际值1.0V
Differential to single ended

Parts:
C22, C53: 100pF/100V; C_0603_1608Metric; MPN 0603B101K101SD
C46, C47, C50, C51, C52: 1uF/25V; C_0603_1608Metric; MPN 0603B105K250XD
C48, C49, C54, C55, C56, C57, C58: 100nF/100V; C_0603_1608Metric; MPN CL10B104KC8NNNC
D9, D10: 1N4148W; D_SOD-123; MPN 1N4148W-7-F
D11: BZT52H-C62; D_SOD-123F; MPN BZT52H-C62,115
D12: LED Red; LED_0603_1608Metric; MPN LTST-C190KRKT
F1, F2, F3, F4, F5, F6, F8, F9, F10, F11, F12, F13, F14: MPZ2012S102ATD25; Fuse_0805_2012Metric; MPN MPZ2012S102ATD25
FB1: BLM18PG330SN1D; R_0603_1608Metric; MPN BLM18PG330SN1D
J13, J14: B7B-XH-A; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical_BAT_6S; MPN B7B-XH-A
J15: PB MB; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical; MPN B2P-VH
Q2: NSV1C201MZ4; SOT-223; MPN NSV1C201MZ4T1G
R53, R54, R61: 100R; R_0603_1608Metric; MPN RC0603FR-07100RL
R55, R57: 0; R_0603_1608Metric; MPN RC0603JR-070RL
R56: 1M; R_0603_1608Metric; MPN RC0603JR-071ML
R58, R62, R63, R64, R65, R67: 100K; R_0603_1608Metric; MPN RC0603JR-07100KL
R59, R66: 1.2K; R_0603_1608Metric; MPN RC0603JR-071K2L
R60: 806R; R_0603_1608Metric; MPN RC0603FR-07806RL
TH1: 100K NTC; R_0603_1608Metric; MPN B57355V5104F360
TH2, TH3, TH4, TH5: 100K NTC; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical; MPN MF52C1104F4150
TP3, TP4: TestPoint; TestPoint_Pad_D1.0mm
TR3: HM2102NL; HM2102NL_PUL; MPN HM2102NL
U12: LTC6811HG-1; TSSOP-48_6.1x12.5mm_P0.5mm; MPN LTC6811HG-1#3ZZPBF

Connections:
/BAT+: D9.1 (K), D10.1 (K), D11.1 (K), FB1.1, R53.1, R54.1; also elsewhere on the board
/LTC6811/C1: F13.1, J14.1 (Pin_2)
/LTC6811/C1_G: F14.1, J14.0 (Pin_1)
/LTC6811/C2: F12.1, J14.2 (Pin_3)
/LTC6811/C3: F11.1, J14.3 (Pin_4)
/LTC6811/C4: F10.1, J14.4 (Pin_5)
/LTC6811/C5: F9.1, J14.5 (Pin_6)
/LTC6811/C6: F8.1, J13.0 (Pin_1), J14.6 (Pin_7)
/LTC6811/C7: F6.1, J13.1 (Pin_2)
/LTC6811/C8: F5.1, J13.2 (Pin_3)
/LTC6811/C9: F4.1, J13.3 (Pin_4)
/LTC6811/C10: F3.1, J13.4 (Pin_5)
/LTC6811/C11: F2.1, J13.5 (Pin_6)
/LTC6811/C12: F1.1, J13.6 (Pin_7)
/LTC6811/DRIVE: Q2.1 (B), U12.38 (DRIVE)
/LTC6811/IMA: R61.2, TR3.12, U12.41 (IMA)
/LTC6811/IMB: R58.1, TR3.9, U12.47 (IMB)
/LTC6811/IPA: R61.1, TR3.10, U12.42 (IPA)
/LTC6811/IPB: R58.2, TR3.7, U12.48 (IPB)
/LTC6811/T1: C58.1, R67.2, TH1.1, U12.27 (GPIO1)
/LTC6811/T2: C54.1, R62.1, TH2.1, U12.28 (GPIO2)
/LTC6811/T3: C55.1, R63.1, TH3.1, U12.29 (GPIO3)
/LTC6811/T4: C56.1, R64.1, TH4.1, U12.32 (GPIO4)
/LTC6811/T5: C57.1, R65.1, TH5.1, U12.33 (GPIO5)
/LTC6811/Vref2: C46.1, R62.2, R63.2, R64.2, R65.2, R67.1, TP4.1, U12.34 (Vref2)
/LTC6811/Vreg: C50.1, C51.1, C52.1, D12.2 (A), Q2.3 (E), R55.2, R56.2, TP3.1, U12.37 (Vreg)
/LTC6811/cell1/C: U12.24 (C1); also elsewhere on the board
/LTC6811/cell1/C+: F13.2; also elsewhere on the board
/LTC6811/cell1/S: U12.25 (S1); also elsewhere on the board
/LTC6811/cell2/C: U12.22 (C2); also elsewhere on the board
/LTC6811/cell2/C+: F12.2; also elsewhere on the board
/LTC6811/cell2/S: U12.23 (S2); also elsewhere on the board
/LTC6811/cell3/C: U12.20 (C3); also elsewhere on the board
/LTC6811/cell3/C+: F11.2; also elsewhere on the board
/LTC6811/cell3/S: U12.21 (S3); also elsewhere on the board
/LTC6811/cell4/C: U12.18 (C4); also elsewhere on the board
/LTC6811/cell4/C+: F10.2; also elsewhere on the board
/LTC6811/cell4/S: U12.19 (S4); also elsewhere on the board
/LTC6811/cell5/C: U12.16 (C5); also elsewhere on the board
/LTC6811/cell5/C+: F9.2; also elsewhere on the board
/LTC6811/cell5/S: U12.17 (S5); also elsewhere on the board
/LTC6811/cell6/C: U12.14 (C6); also elsewhere on the board
/LTC6811/cell6/C+: F8.2; also elsewhere on the board
/LTC6811/cell6/S: U12.15 (S6); also elsewhere on the board
/LTC6811/cell7/C: U12.12 (C7); also elsewhere on the board
/LTC6811/cell7/C+: F6.2; also elsewhere on the board
/LTC6811/cell7/S: U12.13 (S7); also elsewhere on the board
/LTC6811/cell8/C: U12.10 (C8); also elsewhere on the board
/LTC6811/cell8/C+: F5.2; also elsewhere on the board
/LTC6811/cell8/S: U12.11 (S8); also elsewhere on the board
/LTC6811/cell9/S: U12.9 (S9); also elsewhere on the board
/LTC6811/cell10/C: U12.6 (C10); also elsewhere on the board
/LTC6811/cell10/C+: F3.2; also elsewhere on the board
/LTC6811/cell10/C-: F4.2; also elsewhere on the board
/LTC6811/cell10/CM: U12.8 (C9); also elsewhere on the board
/LTC6811/cell10/S: U12.7 (S10); also elsewhere on the board
/LTC6811/cell11/C: U12.4 (C11); also elsewhere on the board
/LTC6811/cell11/C+: F2.2; also elsewhere on the board
/LTC6811/cell11/S: U12.5 (S11); also elsewhere on the board
/LTC6811/cell12/C: U12.2 (C12); also elsewhere on the board
/LTC6811/cell12/C+: F1.2, FB1.2; also elsewhere on the board
/LTC6811/cell12/S: U12.3 (S12); also elsewhere on the board
/MA: TR3.3; also elsewhere on the board
/PA: TR3.1; also elsewhere on the board
unnamed: C22.1, TR3.8
unnamed: C49.1, Q2.2 (C), Q2.4 (C), R53.2
unnamed: C53.1, TR3.11
unnamed: D12.1 (K), R66.1
unnamed: J15.1, TR3.6
unnamed: J15.2, TR3.4
unnamed: R57.1, U12.36 (DTEN)
unnamed: R59.1, U12.45 (IBIAS)
unnamed: R59.2, R60.1, U12.46 (ICMP)
unnamed: R55.1, U12.40 (ISOMD)
unnamed: C48.1, R54.2, U12.1 (V+)
unnamed: C47.1, U12.35 (Vref1)
unnamed: R56.1, U12.39 (WDT)

Notes on the sheet:
In the daisy chain connection R58 is 100 ohms.
2023-10-17
LTC6811_ESP32
12V

Parts:
C59: 100nF/100V; C_0603_1608Metric; MPN CL10B104KC8NNNC
D13: PDZ7.5B; D_SOD-323_HandSoldering; MPN PDZ7.5BZ
Q3: TSM2323; SOT-23; MPN TSM2323CX RFG
R68: 36R 1W 2512; R_2512_6332Metric; MPN RTT25360JTE
R69: 100R; R_0603_1608Metric; MPN RC0603FR-07100RL
R70: 3.3K; R_0603_1608Metric; MPN RC0603FR-073K3L

Connections:
/LTC6811/cell1/C: C59.1, D13.1 (K), R69.1; also elsewhere on the board
/LTC6811/cell1/C+: Q3.2 (S), R69.2; also elsewhere on the board
/LTC6811/cell1/S: R70.1; also elsewhere on the board
unnamed: Q3.3 (D), R68.2
unnamed: Q3.1 (G), R70.2

Parts of its further copies:
C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70: 100nF/100V; C_0603_1608Metric; MPN CL10B104KC8NNNC
D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: PDZ7.5B; D_SOD-323_HandSoldering; MPN PDZ7.5BZ
Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14: TSM2323; SOT-23; MPN TSM2323CX RFG
R71, R74, R77, R80, R83, R86, R89, R92, R95, R98, R101: 36R 1W 2512; R_2512_6332Metric; MPN RTT25360JTE
R72, R75, R78, R81, R84, R87, R90, R93, R96, R99, R102: 100R; R_0603_1608Metric; MPN RC0603FR-07100RL
R73, R76, R79, R82, R85, R88, R91, R94, R97, R100, R103: 3.3K; R_0603_1608Metric; MPN RC0603FR-073K3L

Connections of its further copies:
/LTC6811/cell1/C: D14.2 (A); also elsewhere on the board
/LTC6811/cell1/C+: R71.1; also elsewhere on the board
/LTC6811/cell2/C: C60.1, D14.1 (K), D15.2 (A), R72.1; also elsewhere on the board
/LTC6811/cell2/C+: Q4.2 (S), R72.2, R74.1; also elsewhere on the board
/LTC6811/cell2/S: R73.1; also elsewhere on the board
/LTC6811/cell3/C: C61.1, D15.1 (K), D16.2 (A), R75.1; also elsewhere on the board
/LTC6811/cell3/C+: Q5.2 (S), R75.2, R77.1; also elsewhere on the board
/LTC6811/cell3/S: R76.1; also elsewhere on the board
/LTC6811/cell4/C: C62.1, D16.1 (K), D17.2 (A), R78.1; also elsewhere on the board
/LTC6811/cell4/C+: Q6.2 (S), R78.2, R80.1; also elsewhere on the board
/LTC6811/cell4/S: R79.1; also elsewhere on the board
/LTC6811/cell5/C: C63.1, D17.1 (K), D18.2 (A), R81.1; also elsewhere on the board
/LTC6811/cell5/C+: Q7.2 (S), R81.2, R83.1; also elsewhere on the board
/LTC6811/cell5/S: R82.1; also elsewhere on the board
/LTC6811/cell6/C: C64.1, D18.1 (K), D19.2 (A), R84.1; also elsewhere on the board
/LTC6811/cell6/C+: Q8.2 (S), R84.2, R86.1; also elsewhere on the board
/LTC6811/cell6/S: R85.1; also elsewhere on the board
/LTC6811/cell7/C: C65.1, D19.1 (K), D20.2 (A), R87.1; also elsewhere on the board
/LTC6811/cell7/C+: Q9.2 (S), R87.2, R89.1; also elsewhere on the board
/LTC6811/cell7/S: R88.1; also elsewhere on the board
/LTC6811/cell8/C: C66.1, D20.1 (K), D21.2 (A), R90.1; also elsewhere on the board
/LTC6811/cell8/C+: Q10.2 (S), R90.2, R92.1; also elsewhere on the board
/LTC6811/cell8/S: R91.1; also elsewhere on the board
/LTC6811/cell9/S: R94.1; also elsewhere on the board
/LTC6811/cell10/C: C68.1, D22.1 (K), D23.2 (A), R96.1; also elsewhere on the board
/LTC6811/cell10/C+: Q12.2 (S), R96.2, R98.1; also elsewhere on the board
/LTC6811/cell10/C-: Q11.2 (S), R93.2, R95.1; also elsewhere on the board
/LTC6811/cell10/CM: C67.1, D21.1 (K), D22.2 (A), R93.1; also elsewhere on the board
/LTC6811/cell10/S: R97.1; also elsewhere on the board
/LTC6811/cell11/C: C69.1, D23.1 (K), D24.2 (A), R99.1; also elsewhere on the board
/LTC6811/cell11/C+: Q13.2 (S), R99.2, R101.1; also elsewhere on the board
/LTC6811/cell11/S: R100.1; also elsewhere on the board
/LTC6811/cell12/C: C70.1, D24.1 (K), R102.1; also elsewhere on the board
/LTC6811/cell12/C+: Q14.2 (S), R102.2; also elsewhere on the board
/LTC6811/cell12/S: R103.1; also elsewhere on the board
unnamed: Q4.3 (D), R71.2
unnamed: Q4.1 (G), R73.2
unnamed: Q5.3 (D), R74.2
unnamed: Q5.1 (G), R76.2
unnamed: Q6.3 (D), R77.2
unnamed: Q6.1 (G), R79.2
unnamed: Q7.3 (D), R80.2
unnamed: Q7.1 (G), R82.2
unnamed: Q8.3 (D), R83.2
unnamed: Q8.1 (G), R85.2
unnamed: Q9.3 (D), R86.2
unnamed: Q9.1 (G), R88.2
unnamed: Q10.3 (D), R89.2
unnamed: Q10.1 (G), R91.2
unnamed: Q11.3 (D), R92.2
unnamed: Q11.1 (G), R94.2
unnamed: Q12.3 (D), R95.2
unnamed: Q12.1 (G), R97.2
unnamed: Q13.3 (D), R98.2
unnamed: Q13.1 (G), R100.2
unnamed: Q14.3 (D), R101.2
unnamed: Q14.1 (G), R103.2

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